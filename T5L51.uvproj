# Keil uVision project T5L51.uvproj, settings and files
target Target 1 (MCS-51)
  device: T5 DWIN
  cpu: IRAM(0-0xFF) CLOCK(24000000) MODC2 PMW DPC BSE MDU_R515
  output: T5L51 +hex
  AfterMake: 1.bat
  c flags: Optimize=8 SizeSpeed=1
  c include: .\driver;.\source
  group startup
    ./: STARTUP_M5.A51
  group driver
    ./driver/: sys.c timer.c uart.c canbus.c
  group application
    ./source/: main.c const.c ui.c dwin8283.c ssd2828.c rtc.c
    ./driver/: MYModBus.c ReceiveData.c vars.c
